DESCRIPTION = "meta file for enigma2 softcam packages"

require conf/license/license-gplv2.inc

PROVIDES = "softcams"

DEPENDS = " \
	enigma2-plugin-softcams-cccam \
	enigma2-plugin-softcams-oscam-emu \
	enigma2-plugin-softcams-oscam-smod \
	enigma2-plugin-softcams-ncam \
	enigma2-plugin-softcams-mgcamd \
        enigma2-plugin-softcams-wicardd \
        enigma2-plugin-softcams-oscam-smod \
	"
